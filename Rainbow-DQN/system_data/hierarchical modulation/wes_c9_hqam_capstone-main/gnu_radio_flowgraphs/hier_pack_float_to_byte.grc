options:
  parameters:
    author: Jeff Cuenco
    category: Hierarchical Modulation
    description: Takes float data stream and packs it into byte stream
    generate_options: hb
    id: hier_pack_float_to_byte
    output_language: python
    title: Pack Float to Byte
  states: {}

blocks:
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: scaling_const
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: short
  states: {}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: short
  states: {}
- name: blocks_short_to_char_0_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: scaling_const
  id: parameter
  parameters:
    label: Float to Short Scaling Constant
    type: intx
    value: '1000'
  states: {}

connections:
- [blocks_float_to_short_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_short_to_char_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_short_to_char_0_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_float_to_short_0_0, '0']

metadata:
  file_format: 1
