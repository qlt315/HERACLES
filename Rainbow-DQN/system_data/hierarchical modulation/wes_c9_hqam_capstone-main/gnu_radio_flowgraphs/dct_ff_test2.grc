options:
  parameters:
    author: Jeff Cuenco
    copyright: 2022 Zammerstein Enterprises
    generate_options: qt_gui
    id: dct_test
    output_language: python
    title: DCT Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: scrambler_len
  id: variable
  parameters:
    value: '17'
  states: {}
- name: scrambler_mask
  id: variable
  parameters:
    value: '0x9'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/wes/projects/capstone/hqam_modulation/GNU Radio /Lenna_dct_encoded.dat
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/wes/projects/capstone/hqam_modulation/GNU Radio /Lenna_img_decoded_ee.dat
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("data_start")
    file: /home/wes/projects/capstone/hqam_modulation/GNU Radio /Lenna_raw_gray.dat
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("data_start")
    file: /home/wes/projects/capstone/hqam_modulation/GNU Radio /Lenna_dct_encoded.dat
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("data_start")
    file: /home/wes/projects/capstone/hqam_modulation/GNU Radio /Lenna_img_decoded_ee.dat
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_float_to_short_0_0
  id: blocks_float_to_short
  parameters:
    scale: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '256'
    type: short
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: short
  states: {}
- name: blocks_packed_to_unpacked_xx_1
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_short_to_char_0_0
  id: blocks_short_to_char
  parameters: {}
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: '1000'
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '256'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: short
  states: {}
- name: dct_dct_ff_0
  id: dct_dct_ff
  parameters:
    height: '512'
    mode: '0'
    width: '512'
  states: {}
- name: dct_dct_ff_0_0
  id: dct_dct_ff
  parameters:
    height: '512'
    mode: '1'
    width: '512'
  states: {}
- name: digital_additive_scrambler_bb_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: scrambler_len
    mask: scrambler_mask
    seed: '0x7F'
  states: {state: disabled}
- name: digital_additive_scrambler_bb_0_0
  id: digital_additive_scrambler_bb
  parameters:
    bits_per_byte: '1'
    count: '0'
    len: scrambler_len
    mask: scrambler_mask
    seed: '0x7F'
  states: {state: disabled}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: scrambler_len
    mask: scrambler_mask
    seed: '0x7F'
  states: {state: disabled}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: scrambler_len
    mask: scrambler_mask
    seed: '0x7F'
  states: {state: disabled}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    imageheight: '512'
    imagewidth: '512'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: z1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: z2
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: z2
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: z1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: z2
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: z1
  states: {state: disabled}

connections:
- [analog_sig_source_x_0, '0', show_image_0, '1']
- [blocks_char_to_float_0, '0', dct_dct_ff_0, '0']
- [blocks_char_to_short_0, '0', blocks_short_to_float_1, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_file_source_0, '0', virtual_sink_2, '0']
- [blocks_file_source_0_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_file_source_0_0_0, '0', show_image_0, '0']
- [blocks_float_to_char_0, '0', virtual_sink_1, '0']
- [blocks_float_to_short_0, '0', blocks_unpacked_to_packed_xx_1, '0']
- [blocks_float_to_short_0_0, '0', blocks_packed_to_unpacked_xx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_short_to_char_0_0, '0']
- [blocks_packed_to_unpacked_xx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_packed_to_unpacked_xx_1, '0', blocks_char_to_short_0, '0']
- [blocks_short_to_char_0_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [blocks_short_to_float_0, '0', dct_dct_ff_0_0, '0']
- [blocks_short_to_float_1, '0', blocks_float_to_short_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', digital_additive_scrambler_bb_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', digital_scrambler_bb_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', blocks_file_sink_0, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', virtual_sink_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', blocks_short_to_float_0, '0']
- [dct_dct_ff_0, '0', blocks_float_to_short_0_0, '0']
- [dct_dct_ff_0_0, '0', blocks_float_to_char_0, '0']
- [digital_additive_scrambler_bb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_additive_scrambler_bb_0, '0', digital_additive_scrambler_bb_0_0, '0']
- [digital_additive_scrambler_bb_0_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_descrambler_bb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [digital_scrambler_bb_0, '0', digital_descrambler_bb_0, '0']
- [virtual_source_0, '0', blocks_packed_to_unpacked_xx_1, '0']
- [virtual_source_1, '0', show_image_0, '0']
- [virtual_source_2, '0', show_image_0, '0']

metadata:
  file_format: 1
