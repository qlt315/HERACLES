options:
  parameters:
    author: Jeff Cuenco
    copyright: 2022 Zammerstein Enterprises
    generate_options: qt_gui
    id: dct_test
    output_language: python
    title: DCT Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: scrambler_len
  id: variable
  parameters:
    value: '17'
  states: {}
- name: scrambler_mask
  id: variable
  parameters:
    value: '0x9'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wes/projects/capstone/hqam_modulation/GNU Radio /Lenna_raw_gray.dat
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: dct_dct_ff_0_0_0
  id: dct_dct_ff
  parameters:
    height: '512'
    mode: '1'
    width: '512'
  states: {}
- name: dct_dct_ff_0_0_0_0
  id: dct_dct_ff
  parameters:
    height: '512'
    mode: '1'
    width: '512'
  states: {}
- name: dct_dct_ff_0_0_0_1
  id: dct_dct_ff
  parameters:
    height: '512'
    mode: '1'
    width: '512'
  states: {state: disabled}
- name: dct_height
  id: parameter
  parameters:
    label: DCT Block Height (Rows)
    type: intx
    value: '512'
  states: {}
- name: dct_width
  id: parameter
  parameters:
    label: DCT Block Width (Cols)
    type: intx
    value: '512'
  states: {}
- name: hier_gen_hplp_layers_0
  id: hier_gen_hplp_layers
  parameters:
    dct_height: '512'
    dct_width: '512'
    scaling_const: '1000'
  states: {}
- name: hier_pack_byte_to_float_1
  id: hier_pack_byte_to_float
  parameters:
    scaling_const: '1000'
  states: {}
- name: hier_pack_byte_to_float_1_0
  id: hier_pack_byte_to_float
  parameters:
    scaling_const: '1000'
  states: {}
- name: hier_pack_float_to_byte_0_0
  id: hier_pack_float_to_byte
  parameters:
    scaling_const: '1000'
  states: {state: disabled}
- name: hier_pack_float_to_byte_0_0_0
  id: hier_pack_float_to_byte
  parameters:
    scaling_const: '1000'
  states: {state: disabled}
- name: hqam_split_py_ff_0
  id: hqam_split_py_ff
  parameters:
    height: dct_height
    width: dct_width
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '175'
    ymin: '-175'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    imageheight: '512'
    imagewidth: '512'
  states: {}
- name: show_image_0_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    imageheight: '512'
    imagewidth: '512'
  states: {state: disabled}
- name: show_image_0_0_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    imageheight: '512'
    imagewidth: '512'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: z2
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: z2
  states: {}

connections:
- [analog_sig_source_x_0, '0', show_image_0, '1']
- [analog_sig_source_x_0_0, '0', show_image_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', show_image_0_0_0, '1']
- [blocks_add_xx_0, '0', blocks_float_to_char_0, '0']
- [blocks_add_xx_0, '0', dct_dct_ff_0_0_0_1, '0']
- [blocks_char_to_float_0, '0', hqam_split_py_ff_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_float_to_char_0, '0', virtual_sink_0, '0']
- [dct_dct_ff_0_0_0, '0', blocks_add_xx_0, '0']
- [dct_dct_ff_0_0_0, '0', hier_pack_float_to_byte_0_0, '0']
- [dct_dct_ff_0_0_0_0, '0', blocks_add_xx_0, '1']
- [dct_dct_ff_0_0_0_0, '0', hier_pack_float_to_byte_0_0_0, '0']
- [dct_dct_ff_0_0_0_1, '0', blocks_float_to_char_0, '0']
- [hier_gen_hplp_layers_0, '0', hier_pack_byte_to_float_1, '0']
- [hier_gen_hplp_layers_0, '1', hier_pack_byte_to_float_1_0, '0']
- [hier_pack_byte_to_float_1, '0', dct_dct_ff_0_0_0, '0']
- [hier_pack_byte_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [hier_pack_byte_to_float_1_0, '0', dct_dct_ff_0_0_0_0, '0']
- [hier_pack_float_to_byte_0_0, '0', show_image_0_0, '0']
- [hier_pack_float_to_byte_0_0_0, '0', show_image_0_0_0, '0']
- [hqam_split_py_ff_0, '0', blocks_add_xx_0, '0']
- [hqam_split_py_ff_0, '0', qtgui_time_sink_x_0, '0']
- [hqam_split_py_ff_0, '1', blocks_add_xx_0, '1']
- [hqam_split_py_ff_0, '1', qtgui_time_sink_x_0, '1']
- [virtual_source_1, '0', show_image_0, '0']

metadata:
  file_format: 1
