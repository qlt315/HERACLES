options:
  parameters:
    author: Jeff Cuenco
    copyright: 2022 Zammerstein Enterprises
    generate_options: qt_gui
    id: dct_test
    output_language: python
    title: DCT Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: scrambler_len
  id: variable
  parameters:
    value: '15'
  states: {}
- name: scrambler_mask
  id: variable
  parameters:
    value: '106513'
  states: {}
- name: scrambler_seed
  id: variable
  parameters:
    value: '0x7FFF'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("data_start")
    file: /home/wes/projects/capstone/hqam_modulation/GNU Radio /archive/Lenna_raw_gray.dat
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: dct_enc_bytes_0
  id: dct_enc_bytes
  parameters:
    dct_height: '512'
    dct_width: '512'
  states: {}
- name: digital_descrambler_bb_0_0_0
  id: digital_descrambler_bb
  parameters:
    len: scrambler_len
    mask: scrambler_mask
    seed: scrambler_seed
  states: {}
- name: digital_scrambler_bb_0_0
  id: digital_scrambler_bb
  parameters:
    len: scrambler_len
    mask: scrambler_mask
    seed: scrambler_seed
  states: {}
- name: idct_dec_bytes_0
  id: idct_dec_bytes
  parameters:
    idct_height: '512'
    idct_width: '512'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    marker1: '0'
    marker2: '2'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {state: disabled}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    imageheight: '512'
    imagewidth: '512'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: z1
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: z2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: z1
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: z2
  states: {}

connections:
- [analog_sig_source_x_0, '0', show_image_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_file_source_0, '0', dct_enc_bytes_0, '0']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_0, '0']
- [blocks_pack_k_bits_bb_0_1, '0', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_skiphead_0, '0', idct_dec_bytes_0, '0']
- [blocks_unpack_k_bits_bb_1_0, '0', digital_scrambler_bb_0_0, '0']
- [blocks_unpack_k_bits_bb_1_0_0, '0', digital_descrambler_bb_0_0_0, '0']
- [dct_enc_bytes_0, '0', blocks_char_to_float_0, '0']
- [dct_enc_bytes_0, '0', blocks_unpack_k_bits_bb_1_0, '0']
- [digital_descrambler_bb_0_0_0, '0', blocks_pack_k_bits_bb_0_1, '0']
- [digital_scrambler_bb_0_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_scrambler_bb_0_0, '0', virtual_sink_0, '0']
- [idct_dec_bytes_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_unpack_k_bits_bb_1_0_0, '0']
- [virtual_source_0, '0', digital_descrambler_bb_0_0_0, '0']
- [virtual_source_1, '0', show_image_0, '0']

metadata:
  file_format: 1
