options:
  parameters:
    author: wes
    generate_options: qt_gui
    id: chunks_test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1+1j, -1+1j, 1-1j, -1-1j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: scrambler_len
  id: variable
  parameters:
    value: '15'
  states: {}
- name: scrambler_mask
  id: variable
  parameters:
    value: '106513'
  states: {}
- name: scrambler_seed
  id: variable
  parameters:
    value: '0x7FFF'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '4097'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '4'
    min: '0'
    num_samps: '4097'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.8284'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.4142'
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_2
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_2_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_3
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_4
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[30, 482]'
    type: byte
  states: {state: disabled}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: '[30, 482]'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"lp_packet_len"'
    packet_len: '512'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"hp_packet_len"'
    packet_len: '512'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: hp_packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: lp_packet_len
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,1,1,2,2,1,3,0,3,1,1,1,2,2,3,0,0,0,1,1,1,1,2,2,3,3,2,2,1,3)
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0,1,3,0,2,1,1,3,3,1,2,3,3,1,1,1,2,2,1,1,0,3,0,0,2,2,3,3,1,0)
  states: {state: disabled}
- name: checkevm_getevm_0
  id: checkevm_getevm
  parameters:
    max_evm: '0.7'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constel.points()
  states: {state: disabled}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constel.points()
  states: {state: disabled}
- name: hier_gen_hplp_layers_0
  id: hier_gen_hplp_layers
  parameters:
    dct_height: '512'
    dct_width: '512'
    scaling_const: '1000'
  states: {}
- name: hqam_enc_hp_stream_0
  id: hqam_enc_hp_stream
  parameters:
    scrambler_len: scrambler_len
    scrambler_mask: scrambler_mask
    scrambler_seed: scrambler_seed
  states: {}
- name: hqam_enc_lp_stream_0
  id: hqam_enc_lp_stream
  parameters:
    scrambler_len: scrambler_len
    scrambler_mask: scrambler_mask
    scrambler_seed: scrambler_seed
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"HP"'
    size: '1024'
    type: complex
    xmax: '4'
    xmin: '-4'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"LP"'
    size: '1024'
    type: complex
    xmax: '4'
    xmin: '-4'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    name: '"HP + LP"'
    size: '1024'
    type: complex
    xmax: '4'
    xmin: '-4'
    ymax: '4'
    ymin: '-4'
  states: {}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    name: '"Post-EVM HPLP"'
    size: '30'
    type: complex
    update_time: '1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"HP Time Sink"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"HP"'
    size: '30'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"LP"'
    size: '30'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: zam
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: srczam
  states: {state: disabled}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: srczam2
  states: {state: disabled}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: zhp
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: zlp
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: zam
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: srczam
  states: {state: disabled}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: srczam2
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: zhp
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: zlp
  states: {}

connections:
- [analog_agc_xx_0, '0', checkevm_getevm_0, '0']
- [analog_agc_xx_0, '0', qtgui_const_sink_x_0_0_1, '0']
- [analog_random_source_x_0, '0', blocks_stream_mux_0_0, '1']
- [analog_random_source_x_0_0, '0', blocks_stream_mux_0, '1']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '1']
- [blocks_null_source_0_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_stream_mux_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_stream_mux_0, '0', virtual_sink_1, '0']
- [blocks_stream_mux_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_tagged_stream_to_pdu_0_0, pdus, blocks_message_debug_0_0, print_pdu]
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_mux_0_0, '0']
- [checkevm_getevm_0, '0', blocks_null_sink_0, '0']
- [checkevm_getevm_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [checkevm_getevm_0, '1', blocks_null_sink_0_4, '0']
- [checkevm_getevm_0, '1', blocks_tagged_stream_to_pdu_0_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [hier_gen_hplp_layers_0, '0', hqam_enc_hp_stream_0, '0']
- [hier_gen_hplp_layers_0, '1', hqam_enc_lp_stream_0, '0']
- [hqam_enc_hp_stream_0, '0', virtual_sink_2, '0']
- [hqam_enc_lp_stream_0, '0', virtual_sink_3, '0']
- [virtual_source_0, '0', analog_agc_xx_0, '0']
- [virtual_source_2, '0', blocks_add_xx_0, '0']
- [virtual_source_2, '0', qtgui_const_sink_x_0, '0']
- [virtual_source_3, '0', blocks_add_xx_0, '1']
- [virtual_source_3, '0', qtgui_const_sink_x_0_0, '0']

metadata:
  file_format: 1
