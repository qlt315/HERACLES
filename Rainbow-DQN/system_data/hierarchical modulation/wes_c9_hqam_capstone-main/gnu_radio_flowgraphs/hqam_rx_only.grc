options:
  parameters:
    author: Jeff Cuenco and Ashwini Bhagat
    category: Custom
    description: Explore Soft Decoding of constellations. Selec the constellation from the available objects.
    generate_options: qt_gui
    id: hqam_rx_only
    output_language: python
    title: Hierarchical QAM Mod / Demod Demonstration
  states: {}

blocks:
- name: agc_gain
  id: variable
  parameters:
    value: '0.82'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 2000e6
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_default(header_len, len_tag_key,num_tag_key,1)
  states: {}
- name: header_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_length"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_tag_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: qpsk_const
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: qpsk_preamble
  id: variable
  parameters:
    value: '[(-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (-0.7071067690849304+0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j), (0.7071067690849304+0.7071067690849304j), (0.7071067690849304-0.7071067690849304j), (-0.7071067690849304-0.7071067690849304j)]'
  states: {}
- name: qpsk_preamble_zp
  id: variable
  parameters:
    value: np.concatenate((qpsk_preamble, [0,0,0,0,0,0,0,0]))
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,1.0,1.0/(nfilts*sps), rolloff, int(11*sps*nfilts))
  states: {}
- name: rx_gain_dB
  id: variable
  parameters:
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: scrambler_len
  id: variable
  parameters:
    value: '15'
  states: {}
- name: scrambler_mask
  id: variable
  parameters:
    value: '106513'
  states: {}
- name: scrambler_seed
  id: variable
  parameters:
    value: '0x7FFF'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: agc_gain
    type: complex
  states: {}
- name: analog_pwr_squelch_xx_0
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '1e-4'
    gate: 'True'
    ramp: '0'
    threshold: '-40'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '60'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '2'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repack_bits_bb_0_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: '2'
    type: byte
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '2'
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {}
- name: checkevm_getevm_0
  id: checkevm_getevm
  parameters:
    max_evm: '0.7'
  states: {}
- name: dct_dct_ff_0_0_0
  id: dct_dct_ff
  parameters:
    height: '512'
    mode: '1'
    width: '512'
  states: {}
- name: dct_dct_ff_0_0_0_0
  id: dct_dct_ff
  parameters:
    height: '512'
    mode: '1'
    width: '512'
  states: {}
- name: dd_pll_qam_pll_0
  id: dd_pll_qam_pll
  parameters:
    fn: '1000'
    sample_freq: samp_rate
    zeta: '0.7071'
  states: {}
- name: digital_constellation_decoder_cb_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: qpsk_const
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: scrambler_len
    mask: scrambler_mask
    seed: scrambler_seed
  states: {}
- name: digital_descrambler_bb_0_0
  id: digital_descrambler_bb
  parameters:
    len: scrambler_len
    mask: scrambler_mask
    seed: scrambler_seed
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: int(header_len/2)
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: len_tag_key
    output_symbols: 'False'
    samp_rate: samp_rate
    special_tags: ()
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"corr_est"'
    type: complex
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: qpsk_const.pre_diff_code()
  states: {}
- name: digital_packet_headerparser_b_0_0
  id: digital_packet_headerparser_b
  parameters:
    header_formatter: header_formatter.formatter()
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: fll_est_my_fll_0
  id: fll_est_my_fll
  parameters:
    mark_delay: '129'
    sps: '1'
    symbols: qpsk_preamble_zp
    threshold: '0.7'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: hier_pack_byte_to_float_0
  id: hier_pack_byte_to_float
  parameters:
    scaling_const: '1000'
  states: {}
- name: hier_pack_byte_to_float_0_0
  id: hier_pack_byte_to_float
  parameters:
    scaling_const: '1000'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: notebook
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,1,8,1
    label0: Received Signal
    label1: Received Image
    num_tabs: '2'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: notebook@1
    name: '"Extracted Header Constellation"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'notebook@0 : 1,0'
    name: '"After Header/Payload Demux Constellation"'
    size: '1024'
    type: complex
    xmax: '1.2'
    xmin: '-1.2'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 'notebook@0 : 0,0'
    name: RX Constellation
    size: '1000'
    type: complex
    xmax: '1.2'
    xmin: '-1.2'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: notebook@0
    name: '"RX Spectrum (post-AGC)"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: '"Demodulated Header"'
    size: '32'
    srate: samp_rate
    tr_tag: '"corr_est"'
    type: float
    update_time: '1'
    ymax: '100'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    gui_hint: 'notebook@1 : 0,0'
    imageheight: '512'
    imagewidth: '512'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: carrier_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain_dB
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    num_mboards: '2'
    samp_rate: samp_rate
    start_time: '-5.0'
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: header_in
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: header_in
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_pwr_squelch_xx_0, '0', analog_agc_xx_0, '0']
- [analog_sig_source_x_0, '0', show_image_0, '1']
- [blocks_add_xx_1, '0', blocks_float_to_char_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_char_0, '0', show_image_0, '0']
- [blocks_multiply_const_vxx_1, '0', dct_dct_ff_0_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', dct_dct_ff_0_0_0_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_descrambler_bb_0, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_descrambler_bb_0_0, '0']
- [blocks_repack_bits_bb_0_0_0, '0', blocks_char_to_float_1, '0']
- [blocks_repack_bits_bb_0_0_0, '0', digital_packet_headerparser_b_0_0, '0']
- [blocks_repack_bits_bb_0_1, '0', blocks_skiphead_0_0, '0']
- [blocks_repack_bits_bb_0_1_0, '0', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', hier_pack_byte_to_float_0_0, '0']
- [blocks_skiphead_0_0, '0', hier_pack_byte_to_float_0, '0']
- [blocks_tag_gate_0, '0', checkevm_getevm_0, '0']
- [checkevm_getevm_0, '0', blocks_null_sink_0, '0']
- [checkevm_getevm_0, '0', blocks_repack_bits_bb_0, '0']
- [checkevm_getevm_0, '1', blocks_null_sink_0_0, '0']
- [checkevm_getevm_0, '1', blocks_repack_bits_bb_0_0, '0']
- [dct_dct_ff_0_0_0, '0', blocks_add_xx_1, '0']
- [dct_dct_ff_0_0_0_0, '0', blocks_add_xx_1, '1']
- [dct_dct_ff_0_0_0_0, '0', blocks_null_sink_1, '0']
- [dd_pll_qam_pll_0, '0', fll_est_my_fll_0, '0']
- [digital_constellation_decoder_cb_1, '0', digital_map_bb_0, '0']
- [digital_descrambler_bb_0, '0', blocks_repack_bits_bb_0_1, '0']
- [digital_descrambler_bb_0_0, '0', blocks_repack_bits_bb_0_1_0, '0']
- [digital_header_payload_demux_0, '0', digital_constellation_decoder_cb_1, '0']
- [digital_header_payload_demux_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_header_payload_demux_0, '1', blocks_tag_gate_0, '0']
- [digital_header_payload_demux_0, '1', qtgui_const_sink_x_0_0_0, '0']
- [digital_map_bb_0, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_packet_headerparser_b_0_0, header_data, blocks_message_debug_0, print]
- [digital_packet_headerparser_b_0_0, header_data, digital_header_payload_demux_0, header_data]
- [digital_pfb_clock_sync_xxx_0, '0', dd_pll_qam_pll_0, '0']
- [fll_est_my_fll_0, '0', qtgui_const_sink_x_1, '0']
- [fll_est_my_fll_0, '0', virtual_sink_2, '0']
- [hier_pack_byte_to_float_0, '0', blocks_multiply_const_vxx_1, '0']
- [hier_pack_byte_to_float_0, '0', qtgui_time_sink_x_1_0, '0']
- [hier_pack_byte_to_float_0_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [uhd_usrp_source_0, '0', analog_pwr_squelch_xx_0, '0']
- [virtual_source_2, '0', digital_header_payload_demux_0, '0']

metadata:
  file_format: 1
