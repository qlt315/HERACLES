options:
  parameters:
    author: Jeff Cuenco
    category: Hierarchical Modulation
    description: Takes byte data stream and packs it into float stream
    generate_options: hb
    id: hier_pack_byte_to_float
    output_language: python
    title: Pack Byte to Float
  states: {}

blocks:
- name: blocks_char_to_short_0
  id: blocks_char_to_short
  parameters: {}
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_packed_to_unpacked_xx_1
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: scaling_const
  states: {}
- name: blocks_short_to_float_1
  id: blocks_short_to_float
  parameters:
    scale: '256'
  states: {}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: short
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: scaling_const
  id: parameter
  parameters:
    label: Float to Short Scaling Constant
    type: intx
    value: '1000'
  states: {}

connections:
- [blocks_char_to_short_0, '0', blocks_short_to_float_1, '0']
- [blocks_float_to_short_0, '0', blocks_unpacked_to_packed_xx_1, '0']
- [blocks_packed_to_unpacked_xx_1, '0', blocks_char_to_short_0, '0']
- [blocks_short_to_float_0, '0', pad_sink_0, '0']
- [blocks_short_to_float_1, '0', blocks_float_to_short_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', blocks_short_to_float_0, '0']
- [pad_source_0, '0', blocks_packed_to_unpacked_xx_1, '0']

metadata:
  file_format: 1
