options:
  parameters:
    author: Jeff Cuenco
    category: Hierarchical Modulation
    copyright: 2022 Zammerstein Enterprises
    description: Takes byte stream input, DCT-encodes it, and produces byte stream output
    generate_options: hb
    id: idct_dec_bytes
    output_language: python
    title: Inverse Discrete Cosine Transform (Byte Stream)
  states: {}

blocks:
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: dct_dct_ff_0_0
  id: dct_dct_ff
  parameters:
    height: '512'
    mode: '1'
    width: '512'
  states: {}
- name: hier_pack_byte_to_float_0
  id: hier_pack_byte_to_float
  parameters:
    scaling_const: scaling_const
  states: {}
- name: idct_height
  id: parameter
  parameters:
    label: IDCT Block Height (Rows)
    type: intx
    value: '512'
  states: {}
- name: idct_width
  id: parameter
  parameters:
    label: IDCT Block Width (Cols)
    type: intx
    value: '512'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: scaling_const
  id: parameter
  parameters:
    label: Float to Short Scaling Constant
    type: intx
    value: '1000'
  states: {}

connections:
- [blocks_float_to_char_0, '0', pad_sink_0, '0']
- [dct_dct_ff_0_0, '0', blocks_float_to_char_0, '0']
- [hier_pack_byte_to_float_0, '0', dct_dct_ff_0_0, '0']
- [pad_source_0, '0', hier_pack_byte_to_float_0, '0']

metadata:
  file_format: 1
