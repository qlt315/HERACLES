options:
  parameters:
    author: Tom Rondeau
    category: Custom
    description: Explore Soft Decoding of constellations. Selec the constellation from the available objects.
    generate_options: qt_gui
    id: hqam_txrx_hplp
    output_language: python
    title: Soft Decoder Example
  states: {}

blocks:
- name: agc_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: AGC Gain
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '10'
    value: '0.65'
  states: {}
- name: arity
  id: variable
  parameters:
    value: '4'
  states: {}
- name: c_norm
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: HQAM Envelope Amplitude
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.01'
    stop: '2'
    value: '0.17'
  states: {}
- name: carrier_freq
  id: variable
  parameters:
    value: 2000e6
  states: {}
- name: cons
  id: variable_constellation
  parameters:
    const_points: '[(-4-4j), (-2-4j), (2-4j), (4-4j), (-4-2j), (-2-2j), (2-2j), (4-2j), (-4+2j), (-2+2j), (2+2j), (4+2j), (-4+4j), (-2+4j), (2+4j), (4+4j)]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10]'
    type: calcdist
  states: {state: disabled}
- name: cons_norm
  id: variable_constellation
  parameters:
    const_points: '[(-1-1j), (-0.5-1j), (0.5-1j), (1-1j), (-1-0.5j), (-0.5-0.5j), (0.5-0.5j), (1-0.5j), (-1+0.5j), (-0.5+0.5j), (0.5+0.5j), (1+0.5j), (-1+1j), (-0.5+1j), (0.5+1j), (1+1j)]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 4, 12, 8, 1, 5, 13, 9, 3, 7, 15, 11, 2, 6, 14, 10]'
    type: calcdist
  states: {}
- name: constel_hp
  id: variable_constellation
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: constel_lp
  id: variable_constellation
  parameters:
    const_points: '[-3-3j, -3+3j, 3+3j, 3-3j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: corr_calc
  id: variable
  parameters:
    value: corr_thresh/(corr_max*corr_max)
  states: {}
- name: corr_max
  id: variable
  parameters:
    value: numpy.abs(numpy.dot(modulated_sync_word,numpy.conj(modulated_sync_word)))
  states: {}
- name: corr_thresh
  id: variable_qtgui_range
  parameters:
    gui_hint: 5,2,1,1
    label: Absolute Corr Thresh (Mag Sq)
    orient: Qt.Horizontal
    start: '0.1'
    step: '1.0'
    stop: 5e6
    value: '100000'
  states: {}
- name: delay
  id: variable
  parameters:
    value: '58'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,2,1,1
    min_len: '10'
    orient: Qt.Horizontal
    start: '0'
    step: '0.1'
    stop: '10'
    value: '3'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '.001'
  states: {}
- name: modulated_sync_word
  id: variable
  parameters:
    comment: |-
      Note that the modulated sync word
      as generated by Modulate Vector
      block has some filtering transients.

      Offset to the beginning of the 
      actual preamble
    value: '[1, 1, 1, 1, 1, 1, 1, -1, 1, -1, 1, -1, 1, -1, -1, 1, 1, -1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, -1, -1, 1, -1, 1, 1, -1, -1, -1, 1, 1, -1, 1, 1, 1, 1, -1, 1, 1, -1, 1, -1, 1, 1, -1, 1, 1, -1, -1, 1, -1, -1, 1, -1, -1, -1, 1, 1, 1, 1, 1, 1, 1, -1, 1, -1, 1, -1, 1, -1, -1, 1, 1, -1, -1, 1, 1, 1, -1, 1, 1, 1, -1, 1, -1, -1, 1, -1, 1, 1, -1, -1, -1, 1, 1, -1, 1, 1, 1, 1, -1, 1, 1, -1, 1, -1, 1, 1, -1, 1, 1, -1, -1, 1, -1, -1, 1, -1, -1, -1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_taps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: p_norm
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,2,1,1
    label: HQAM Preamble Amplitude
    orient: Qt.Horizontal
    start: '0.1'
    step: '0.01'
    stop: '10'
    value: '4.70'
  states: {}
- name: pi
  id: variable
  parameters:
    value: np.pi
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0, 1, 1, 1, 1, 1, 1, 1, 0, 1, 0, 1, 0, 1, 0, 0, 1, 1, 0, 0, 1, 1, 1, 0, 1, 1, 1, 0, 1, 0, 0, 1, 0, 1, 1, 0, 0, 0, 1, 1, 0, 1, 1, 1, 1, 0, 1, 1, 0, 1, 0, 1, 1, 0, 1, 1, 0, 0, 1, 0, 0, 1, 0, 0, 0]'
  states: {}
- name: preamble_symbols
  id: variable
  parameters:
    value: helpers.map_symbols_to_constellation(helpers.unpack_values(preamble, 8, 4), cons)
  states: {state: disabled}
- name: qpsk_preamble
  id: variable
  parameters:
    value: '[0.7071 + 0.7071j, 0.7071 + 0.7071j, 0.7071 + 0.7071j, 0.7071 - 0.7071j, 0.7071 - 0.7071j, 0.7071 - 0.7071j, 0.7071 - 0.7071j, -0.7071 + 0.7071j, 0.7071 - 0.7071j,-0.7071 + 0.7071j, 0.7071 + 0.7071j,-0.7071 + 0.7071j, 0.7071 + 0.7071j,-0.7071 + 0.7071j, -0.7071 - 0.7071j, 0.7071 - 0.7071j, 0.7071 + 0.7071j,-0.7071 - 0.7071j,-0.7071 + 0.7071j, 0.7071 - 0.7071j, 0.7071 + 0.7071j, 0.7071 + 0.7071j,-0.7071 + 0.7071j, 0.7071 - 0.7071j, 0.7071 - 0.7071j, 0.7071 + 0.7071j,-0.7071 + 0.7071j, 0.7071 - 0.7071j, -0.7071 + 0.7071j,-0.7071 - 0.7071j, 0.7071 - 0.7071j,-0.7071 - 0.7071j, 0.7071 + 0.7071j, 0.7071 + 0.7071j, 0.7071 + 0.7071j, 0.7071 - 0.7071j, 0.7071 - 0.7071j, 0.7071 - 0.7071j, 0.7071 - 0.7071j,-0.7071 + 0.7071j, 0.7071 - 0.7071j,-0.7071 + 0.7071j, 0.7071 + 0.7071j,-0.7071 + 0.7071j, 0.7071 + 0.7071j,-0.7071 + 0.7071j,-0.7071 - 0.7071j, 0.7071 - 0.7071j, 0.7071 + 0.7071j, -0.7071 - 0.7071j,-0.7071 + 0.7071j, 0.7071 - 0.7071j, 0.7071 + 0.7071j, 0.7071 + 0.7071j,-0.7071 + 0.7071j, 0.7071 - 0.7071j, 0.7071 - 0.7071j, 0.7071 + 0.7071j,-0.7071 + 0.7071j, 0.7071 - 0.7071j,-0.7071 + 0.7071j,-0.7071 - 0.7071j, 0.7071 - 0.7071j, -0.7071 - 0.7071j]'
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,1.0,1.0/(nfilts*sps), rolloff, int(11*sps*nfilts))
  states: {}
- name: rx_gain_dB
  id: variable
  parameters:
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_gain_dB
  id: variable
  parameters:
    value: '10'
  states: {}
- name: alg
  id: variable_adaptive_algorithm
  parameters:
    cons: cons
    delta: '40'
    ffactor: '0.999'
    modulus: '4'
    step_size: gain
    type: lms
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '65536'
    rate: '1e-4'
    reference: agc_gain
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1'
    type: float
  states: {state: disabled}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: freq_offset
    type: float
  states: {state: disabled}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '255'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: int(toggle)
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_SQR_WAVE
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_magphase_0
  id: blocks_complex_to_magphase
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {state: disabled}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '64'
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '0'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/wes/capstone/hqam_demo/pak/demod_unpacked_img.dat
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/wes/capstone/hqam_demo/pak/demod_repacked_img_hp.dat
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/bhagat/txrx_demo_new/dct_hp_stream.dat
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/bhagat/txrx_demo_new/dct_lp_stream.dat
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_magphase_to_complex_0
  id: blocks_magphase_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '100'
    max_iter: '10'
    scale: 1/3
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: c_norm
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.8284'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1.4142'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: p_norm
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: blocks_plateau_detector_fb_0
  id: blocks_plateau_detector_fb
  parameters:
    max_len: '64'
    threshold: '15'
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: delay
    type: byte
  states: {state: disabled}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: '[128, 512]'
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_source_x_0_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: ''
    type: complex
    vector: qpsk_preamble
  states: {}
- name: coarsefreq_c_freq_offset_0
  id: coarsefreq_c_freq_offset
  parameters:
    packet_len: '640'
    sample_freq: samp_rate
    threshold: '15'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constel_hp.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constel_lp.points()
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {state: disabled}
- name: digital_lms_dd_equalizer_cc_1
  id: digital_lms_dd_equalizer_cc
  parameters:
    cnst: cons_norm
    mu: gain
    num_taps: num_taps
    sps: '1'
  states: {state: disabled}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[0, 1, 3, 2]'
  states: {state: disabled}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '8'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: digital_scrambler_bb_0_0
  id: digital_scrambler_bb
  parameters:
    len: '8'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: helpers
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph


      def unpack_values(values_in, bits_per_value, bits_per_symbol):   
          # verify that 8 is divisible by bits_per_symbol 
          m = bits_per_value / bits_per_symbol
          # print(m)
          mask = 2**(bits_per_symbol)-1
              
          if bits_per_value != m*bits_per_symbol:
              print("error - bits per symbols must fit nicely into bits_per_value bit values")
              return []
              
          num_values = len(values_in)
          # print(num_values)
          num_symbols = int(num_values*( m) )
          # print(num_symbols)
          cur_byte = 0
          cur_bit = 0
          out = []
          for i in range(num_symbols):
              s = (values_in[cur_byte] >> (bits_per_value-bits_per_symbol-cur_bit)) & mask
              out.append(s)
              cur_bit += bits_per_symbol
              
              if cur_bit >= bits_per_value:
                  cur_bit = 0
                  cur_byte += 1
                  
              # if cur_byte >= num_values:
                  # break;
                  
          return out
          
      def map_symbols_to_constellation(symbols, cons):
          # print("symbols:")
          # print(symbols)
          # print("points:")
          # print(cons.points())
          l = list(map(lambda x: cons.points()[x], symbols))
          # print("Training Symbols")
          # print(l)
          return l
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: notebook
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,1,8,1
    label0: Transmitted Signal
    label1: Received Signal
    num_tabs: '2'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: sps
    taps: firdes.root_raised_cosine(nfilts, 1.0, 1.0/nfilts, rolloff, int(11*sps*nfilts))
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: notebook@0
    name: '"TX Constellation"'
    size: '1024'
    type: complex
    xmax: '1.2'
    xmin: '-1.2'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: notebook@1
    name: RX Constellation
    size: '1000'
    type: complex
    xmax: '1.2'
    xmin: '-1.2'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    name: '"directly from poly"'
    size: '1000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: notebook@0
    name: '"TX Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: notebook@1
    name: '"RX Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 2,0,2,1
    label1: Decoded Data
    marker1: '7'
    name: ''
    size: '200'
    srate: samp_rate
    type: float
    update_time: '0.05'
    ymax: '1.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: notebook@0
    name: '"TX Time Series"'
    size: '200'
    srate: samp_rate
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: notebook@1
    name: '"RX Time Series"'
    size: '200'
    srate: samp_rate
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Correlator Output"'
    size: '1024'
    srate: samp_rate
    type: complex
    update_time: '1'
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_3
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '1'
  states: {state: disabled}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    gui_hint: 0,2,2,1
    imageheight: '512'
    imagewidth: '512'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: carrier_freq
    dev_args: '""'
    gain0: tx_gain_dB
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: carrier_freq
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_gain_dB
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    num_mboards: '2'
    samp_rate: samp_rate
    stream_chans: '[1]'
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: png_decoded_display
  states: {state: disabled}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: png_decoded_display
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [analog_const_source_x_0, '0', blocks_magphase_to_complex_0, '0']
- [analog_const_source_x_1, '0', blocks_magphase_to_complex_0, '1']
- [analog_random_source_x_0, '0', blocks_unpack_k_bits_bb_1_0, '0']
- [analog_random_source_x_0_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [analog_sig_source_x_0, '0', show_image_0, '1']
- [blocks_add_xx_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_magphase_0, '0', blocks_null_sink_0, '0']
- [blocks_complex_to_magphase_0, '1', qtgui_time_sink_x_3, '0']
- [blocks_complex_to_real_0, '0', blocks_plateau_detector_fb_0, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_delay_1, '0', blocks_multiply_xx_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_file_source_0_0, '0', blocks_unpack_k_bits_bb_1_0, '0']
- [blocks_magphase_to_complex_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_magphase_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_real_0, '0']
- [blocks_moving_average_xx_0, '0', coarsefreq_c_freq_offset_0, '1']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_stream_mux_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_const_sink_x_1, '0']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_file_sink_0_0_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', virtual_sink_2, '0']
- [blocks_pack_k_bits_bb_0_1, '0', digital_chunks_to_symbols_xx_0_0_0, '0']
- [blocks_plateau_detector_fb_0, '0', blocks_char_to_float_1, '0']
- [blocks_skiphead_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [blocks_stream_mux_0_0, '0', pfb_arb_resampler_xxx_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_file_sink_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_skiphead_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', digital_scrambler_bb_0, '0']
- [blocks_unpack_k_bits_bb_1_0, '0', digital_scrambler_bb_0_0, '0']
- [blocks_vector_source_x_0_0_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [coarsefreq_c_freq_offset_0, '0', qtgui_const_sink_x_1, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [digital_chunks_to_symbols_xx_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_map_bb_0_0, '0']
- [digital_lms_dd_equalizer_cc_1, '0', qtgui_const_sink_x_1, '0']
- [digital_lms_dd_equalizer_cc_1, '0', qtgui_freq_sink_x_0_0, '0']
- [digital_lms_dd_equalizer_cc_1, '0', qtgui_time_sink_x_1_0, '0']
- [digital_map_bb_0_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_delay_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_delay_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', coarsefreq_c_freq_offset_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_lms_dd_equalizer_cc_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_2, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_time_sink_x_1, '0']
- [digital_scrambler_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_scrambler_bb_0_0, '0', blocks_pack_k_bits_bb_0_1, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [uhd_usrp_source_0, '0', analog_agc_xx_0, '0']
- [virtual_source_2, '0', show_image_0, '0']

metadata:
  file_format: 1
