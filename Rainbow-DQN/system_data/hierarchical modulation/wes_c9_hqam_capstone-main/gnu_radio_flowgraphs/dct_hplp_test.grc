options:
  parameters:
    author: Jeff Cuenco
    generate_options: qt_gui
    id: dct_hplp_test
    output_language: python
    title: DCT HP/LP Split Test
  states: {}

blocks:
- name: dct_height
  id: variable
  parameters:
    value: '512'
  states: {}
- name: dct_width
  id: variable
  parameters:
    value: '512'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: scaling_const
  id: variable_qtgui_range
  parameters:
    label: Post-DCT  Float to Fixed Point Scaling Constant
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '2000'
    value: '1000'
  states: {}
- name: variable_qtgui_range_0
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '60'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '60'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '60'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: byte
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wes/projects/capstone/hqam_modulation/GNU Radio /Lenna_raw_gray.dat
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '1'
  states: {}
- name: dct_dct_ff_0_0
  id: dct_dct_ff
  parameters:
    height: dct_height
    mode: '0'
    width: dct_width
  states: {}
- name: hier_pack_float_to_byte_0
  id: hier_pack_float_to_byte
  parameters:
    scaling_const: scaling_const
  states: {}
- name: hier_pack_float_to_byte_0_0
  id: hier_pack_float_to_byte
  parameters:
    scaling_const: scaling_const
  states: {}
- name: hqam_split_py_ff_0
  id: hqam_split_py_ff
  parameters:
    height: dct_height
    width: dct_width
  states: {}
- name: idct_dec_bytes_0
  id: idct_dec_bytes
  parameters:
    idct_height: dct_width
    idct_width: dct_height
    scaling_const: '1000'
  states: {}
- name: idct_dec_bytes_0_0
  id: idct_dec_bytes
  parameters:
    idct_height: dct_width
    idct_width: dct_height
    scaling_const: '1000'
  states: {}
- name: show_image_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    imageheight: '512'
    imagewidth: '512'
  states: {}
- name: show_image_0_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    imageheight: '512'
    imagewidth: '512'
  states: {}
- name: show_image_0_0_0
  id: show_image
  parameters:
    displaybottomup: 'False'
    imageheight: '512'
    imagewidth: '512'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: hp_img
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: lp_img
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: hp_img
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: lp_img
  states: {}

connections:
- [analog_sig_source_x_0, '0', show_image_0, '1']
- [analog_sig_source_x_0_0, '0', show_image_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', show_image_0_0_0, '1']
- [blocks_add_xx_0, '0', blocks_float_to_char_0, '0']
- [blocks_char_to_float_0, '0', dct_dct_ff_0_0, '0']
- [blocks_char_to_float_1, '0', blocks_add_xx_0, '0']
- [blocks_char_to_float_1_0, '0', blocks_add_xx_0, '1']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [blocks_float_to_char_0, '0', show_image_0_0_0, '0']
- [dct_dct_ff_0_0, '0', hqam_split_py_ff_0, '0']
- [hier_pack_float_to_byte_0, '0', idct_dec_bytes_0, '0']
- [hier_pack_float_to_byte_0_0, '0', idct_dec_bytes_0_0, '0']
- [hqam_split_py_ff_0, '0', hier_pack_float_to_byte_0, '0']
- [hqam_split_py_ff_0, '1', hier_pack_float_to_byte_0_0, '0']
- [idct_dec_bytes_0, '0', virtual_sink_0, '0']
- [idct_dec_bytes_0_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', blocks_char_to_float_1, '0']
- [virtual_source_0, '0', show_image_0, '0']
- [virtual_source_0_0, '0', blocks_char_to_float_1_0, '0']
- [virtual_source_0_0, '0', show_image_0_0, '0']

metadata:
  file_format: 1
