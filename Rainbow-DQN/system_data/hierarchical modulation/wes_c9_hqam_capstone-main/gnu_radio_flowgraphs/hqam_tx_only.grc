options:
  parameters:
    author: Jeff Cuenco and Ashwini Bhagat
    category: Custom
    description: Explore Soft Decoding of constellations. Selec the constellation from the available objects.
    generate_options: qt_gui
    id: hqam_tx_only
    output_language: python
    title: Hierarchical QAM Mod / Demod Demonstration
  states: {}

blocks:
- name: carrier_freq
  id: variable
  parameters:
    value: 2000e6
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: digital.packet_header_default(header_len, len_tag_key,num_tag_key,1)
  states: {}
- name: header_len
  id: variable
  parameters:
    value: '32'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_length"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: num_tag_key
  id: variable
  parameters:
    value: '"packet_num"'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0,0,0,0,0,0,1,0,0,0,1,1,1,0,0,0,1,0,0,1,0,1,1,1,0,0,0,0,0,0,1,1,0,0,1,0,0,1,0,0,1,1,0,1,1,1,0,0,1,0,0,0,0,0,1,0,1,0,1,1,0,1,1,0,1,0,1,1,0,0,1,0,1,1,0,0,0,0,1,1,1,1,1,0,1,1,0,1,1,1,1,0,1,0,1,1,1,0,1,0,0,0,1,0,0,0,0,1,1,0,1,1,0,0,0,1,1,1,1,0,0,1,1,1,0,0,1,1,0,0,0,1,0,1,1,0,1,0,0,1,0,0,0,1,0,1,0,0,1,0,1,0,1,0,0,1,1,1,0,1,1,1,0,1,1,0,0,1,1,1,1,0,1,1,1,1,1,1,0,1,0,0,1,1,0,0,1,1,0,1,0,1,0,0,0,1,1,0,0,0,0,0,1,1,1,0,1,0,1,0,1,0,1,1,1,1,1,0,0,1,0,1,0,0,0,0,1,0,0,1,1,1,1,1,1,1,1,0,0,0,0,1,0,1,1,1,1,0,0,0,1,1,0,1,0,0]'
  states: {}
- name: qpsk_const
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: rolloff
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts,1.0,1.0/(nfilts*sps), rolloff, int(11*sps*nfilts))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: scrambler_len
  id: variable
  parameters:
    value: '15'
  states: {}
- name: scrambler_mask
  id: variable
  parameters:
    value: '106513'
  states: {}
- name: scrambler_seed
  id: variable
  parameters:
    value: '0x7FFF'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_gain_dB
  id: variable
  parameters:
    value: '10'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.17'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '4.2'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_length"'
    packet_len: '512'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_length"'
    packet_len: int((len(preamble) + header_len)/2)
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_length
    ninputs: '2'
    type: complex
  states: {}
- name: digital_pfb_clock_sync_xxx_0_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: hier_gen_hplp_layers_0
  id: hier_gen_hplp_layers
  parameters:
    dct_height: '512'
    dct_width: '512'
    scaling_const: '1000'
  states: {}
- name: hier_hqam_build_hdr_0
  id: hier_hqam_build_hdr
  parameters:
    const_sym_table: qpsk_const.points()
    payload_len: '512'
    preamble: preamble
  states: {}
- name: hqam_enc_hp_stream_0
  id: hqam_enc_hp_stream
  parameters:
    scrambler_len: scrambler_len
    scrambler_mask: scrambler_mask
    scrambler_seed: scrambler_seed
  states: {}
- name: hqam_enc_lp_stream_0
  id: hqam_enc_lp_stream
  parameters:
    scrambler_len: scrambler_len
    scrambler_mask: scrambler_mask
    scrambler_seed: scrambler_seed
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: notebook
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,1,8,1
    label0: Transmitted Signal
    label1: Transmitted Constellation
    num_tabs: '2'
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: '32'
    rrate: sps
    taps: firdes.root_raised_cosine(nfilts, 1.0, 1.0/nfilts, rolloff, int(11*sps*nfilts))
    type: ccf
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: notebook@1
    name: '"TX Constellation"'
    size: '1024'
    type: complex
    xmax: '1.2'
    xmin: '-1.2'
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: notebook@0
    name: '"TX Spectrum"'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: notebook@0
    name: '"TX Time Series"'
    size: '200'
    srate: samp_rate
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: carrier_freq
    dev_args: '""'
    gain0: tx_gain_dB
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_out
  states: {}

connections:
- [blocks_add_xx_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_multiply_const_vxx_0_2, '0']
- [blocks_tagged_stream_mux_0, '0', pfb_arb_resampler_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_pfb_clock_sync_xxx_0_0, '0', qtgui_time_sink_x_1, '0']
- [hier_gen_hplp_layers_0, '0', hqam_enc_hp_stream_0, '0']
- [hier_gen_hplp_layers_0, '1', hqam_enc_lp_stream_0, '0']
- [hier_hqam_build_hdr_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [hqam_enc_hp_stream_0, '0', blocks_add_xx_0, '0']
- [hqam_enc_lp_stream_0, '0', blocks_add_xx_0, '1']
- [pfb_arb_resampler_xxx_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', digital_pfb_clock_sync_xxx_0_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
