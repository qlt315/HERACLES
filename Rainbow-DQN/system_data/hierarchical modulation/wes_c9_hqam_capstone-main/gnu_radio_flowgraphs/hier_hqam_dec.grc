options:
  parameters:
    author: Jeff Cuenco
    category: Hierarchical Modulation
    generate_options: hb
    id: hier_hqam_dec_bits
    output_language: python
    title: Decode HQAM Bitstream
  states: {}

blocks:
- name: bits_per_symbol
  id: parameter
  parameters:
    label: Constellation Bits Per Symbol
    type: intx
    value: '2'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: bits_per_symbol
  states: {}
- name: digital_descrambler_bb_0
  id: digital_descrambler_bb
  parameters:
    len: scrambler_len
    mask: scrambler_mask
    seed: scrambler_seed
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: scrambler_len
  id: parameter
  parameters:
    label: Scrambler Length
    type: intx
    value: '15'
  states: {}
- name: scrambler_mask
  id: parameter
  parameters:
    label: Scrambler Mask
    type: intx
    value: '106513'
  states: {}
- name: scrambler_seed
  id: parameter
  parameters:
    label: Scrambler Seed
    type: intx
    value: '0x7FFF'
  states: {}

connections:
- [blocks_pack_k_bits_bb_0_0_0, '0', blocks_skiphead_0_0, '0']
- [blocks_skiphead_0_0, '0', pad_sink_0, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', digital_descrambler_bb_0, '0']
- [digital_descrambler_bb_0, '0', blocks_pack_k_bits_bb_0_0_0, '0']
- [pad_source_0, '0', blocks_unpack_k_bits_bb_0_0, '0']

metadata:
  file_format: 1
