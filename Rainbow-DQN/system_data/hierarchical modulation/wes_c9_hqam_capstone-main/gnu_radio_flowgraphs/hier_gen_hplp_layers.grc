options:
  parameters:
    author: Jeff Cuenco
    category: Hierarchical Modulation
    description: Takes Lenna grayscale image and splits into HP and LP layers
    generate_options: hb
    id: hier_gen_hplp_layers
    output_language: python
    title: DCT to HP/LP
  states: {}

blocks:
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/wes/projects/capstone/hqam_modulation/GNU Radio /Lenna_raw_gray.dat
    repeat: 'True'
    type: byte
  states: {}
- name: dct_dct_ff_0_0
  id: dct_dct_ff
  parameters:
    height: dct_height
    mode: '0'
    width: dct_width
  states: {}
- name: dct_height
  id: parameter
  parameters:
    label: DCT Block Height (Rows)
    type: intx
    value: '512'
  states: {}
- name: dct_width
  id: parameter
  parameters:
    label: DCT Block Width (Cols)
    type: intx
    value: '512'
  states: {}
- name: hier_pack_float_to_byte_0
  id: hier_pack_float_to_byte
  parameters:
    scaling_const: '1000'
  states: {}
- name: hier_pack_float_to_byte_0_0
  id: hier_pack_float_to_byte
  parameters:
    scaling_const: '1000'
  states: {}
- name: hqam_split_py_ff_0
  id: hqam_split_py_ff
  parameters:
    height: dct_height
    width: dct_width
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: scaling_const
  id: parameter
  parameters:
    label: Float to Short Scaling Constant
    type: intx
    value: '1000'
  states: {}

connections:
- [blocks_char_to_float_0, '0', dct_dct_ff_0_0, '0']
- [blocks_file_source_0, '0', blocks_char_to_float_0, '0']
- [dct_dct_ff_0_0, '0', hqam_split_py_ff_0, '0']
- [hier_pack_float_to_byte_0, '0', pad_sink_0, '0']
- [hier_pack_float_to_byte_0_0, '0', pad_sink_0_0, '0']
- [hqam_split_py_ff_0, '0', hier_pack_float_to_byte_0, '0']
- [hqam_split_py_ff_0, '1', hier_pack_float_to_byte_0_0, '0']

metadata:
  file_format: 1
