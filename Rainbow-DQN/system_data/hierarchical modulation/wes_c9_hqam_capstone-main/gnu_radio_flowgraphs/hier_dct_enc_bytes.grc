options:
  parameters:
    author: Jeff Cuenco
    category: Hierarchical Modulation
    copyright: 2022 Zammerstein Enterprises
    description: Takes byte stream input, DCT-encodes it, and produces byte stream output
    generate_options: hb
    id: dct_enc_bytes
    output_language: python
    title: Discrete Cosine Transform (Byte Stream)
  states: {}

blocks:
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: dct_dct_ff_0_0
  id: dct_dct_ff
  parameters:
    height: dct_height
    mode: '0'
    width: dct_width
  states: {}
- name: dct_height
  id: parameter
  parameters:
    label: DCT Block Height (Rows)
    type: intx
    value: '512'
  states: {}
- name: dct_width
  id: parameter
  parameters:
    label: DCT Block Width (Cols)
    type: intx
    value: '512'
  states: {}
- name: hier_pack_float_to_byte_0
  id: hier_pack_float_to_byte
  parameters:
    scaling_const: '1000'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}

connections:
- [blocks_char_to_float_0, '0', dct_dct_ff_0_0, '0']
- [dct_dct_ff_0_0, '0', hier_pack_float_to_byte_0, '0']
- [hier_pack_float_to_byte_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', blocks_char_to_float_0, '0']

metadata:
  file_format: 1
