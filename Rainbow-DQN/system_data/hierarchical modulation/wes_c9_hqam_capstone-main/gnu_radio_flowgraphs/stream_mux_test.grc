options:
  parameters:
    author: Jeff Cuenco
    generate_options: qt_gui
    id: stream_mux_test
    output_language: python
    title: Stream Mux Test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: '[1,1]'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"hp_packet_len"'
    packet_len: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: hp_packet_len
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: (1+1j,3+3j,5+5j,7+7j,9+9j,11+11j,13+13j,15+15j,17+17j,19+19j,21+21j,23+23j, 25+25j, 27+27j, 29+29j, 31+31j, 33+33j, 35+35j, 37+37j, 39+39j)
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'False'
    type: complex
    vector: (2+2j,4+4j,6+6j,8+8j,10+10j,12+12j,14+14j,16+16j,18+18j,20+20j,22+22j,24+24j,26+26j,28+28j,30+30j,32+32j,34+34j,36+36j,38+38j,40+40j)
  states: {}

connections:
- [blocks_stream_mux_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, blocks_message_debug_0, print_pdu]
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_mux_0, '1']

metadata:
  file_format: 1
