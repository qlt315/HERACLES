options:
  parameters:
    author: Jeff Cuenco
    category: Hierarchical Modulation
    generate_options: hb
    id: hqam_enc_hp_stream
    output_language: python
    title: Encode HQAM High Priority Stream
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1+1j, -1+1j, 1-1j, -1-1j]'
    dims: '1'
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '2.8284'
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '2'
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constel.points()
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: scrambler_len
    mask: scrambler_mask
    seed: scrambler_seed
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    optional: 'True'
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: scrambler_len
  id: parameter
  parameters:
    label: Scrambler Length
    type: intx
    value: '15'
  states: {}
- name: scrambler_mask
  id: parameter
  parameters:
    label: Scrambler Mask
    type: intx
    value: '106513'
  states: {}
- name: scrambler_seed
  id: parameter
  parameters:
    label: Scrambler Seed
    type: intx
    value: '0x7FFF'
  states: {}

connections:
- [blocks_multiply_const_vxx_0_1, '0', pad_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_repack_bits_bb_0, '0', pad_sink_1, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_scrambler_bb_0, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [digital_scrambler_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [pad_source_0, '0', blocks_repack_bits_bb_0_0, '0']

metadata:
  file_format: 1
